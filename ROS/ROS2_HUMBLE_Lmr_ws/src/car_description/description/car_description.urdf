Commit message: change

File: ROS/ROS2_HUMBLE_Lmr_ws/src/car_description/description/car_description.urdf (robot description, URDF)
Before this commit: robot mini_car, 3 links, 2 joints
Joints:
- joint imu_joint: origin xyz=0.02 0 0.01 -> xyz=0 0 0.01
